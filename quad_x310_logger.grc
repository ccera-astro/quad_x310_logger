options:
  parameters:
    generate_options: no_gui
    id: quad_x310_logger
    output_language: python
    run_options: run
    title: X310 Quad Logger
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: irate
  id: variable
  parameters:
    comment: MUST be multiple of 5, >= 10
    value: '15'
  states: {}
- name: log10_k
  id: variable
  parameters:
    value: '-20*math.log10(fft_size)-10*math.log10(winpower/fft_size)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: winpower
  id: variable
  parameters:
    value: sum([x*x for x in window.blackman_harris(fft_size)])
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '4'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fft_size/irate)
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fft_size/irate)
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fft_size/irate)
    type: float
    vlen: fft_size
  states: {}
- name: blocks_keep_one_in_n_0_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/fft_size/irate)
    type: float
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: caldev
  id: parameter
  parameters:
    label: '"Calibration control TTY device"'
    type: str
    value: '""'
  states: {}
- name: caldur
  id: parameter
  parameters:
    label: '"Calibration duration, seconds"'
    type: eng_float
    value: '0.0'
  states: {}
- name: caltimes
  id: parameter
  parameters:
    label: '"Calibration times, decimalized LMST"'
    type: str
    value: '""'
  states: {}
- name: decln
  id: parameter
  parameters:
    label: '"Local Declination"'
    type: eng_float
    value: '0.0'
  states: {}
- name: f1
  id: parameter
  parameters:
    label: '"Frequency 1"'
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: f2
  id: parameter
  parameters:
    label: '"Frequency 2"'
    type: eng_float
    value: 1420.4058e6
  states: {}
- name: f3
  id: parameter
  parameters:
    label: '"Frequency 3"'
    type: eng_float
    value: 611e6
  states: {}
- name: f4
  id: parameter
  parameters:
    label: '"Frequency 4"'
    type: eng_float
    value: 1000e6
  states: {}
- name: fft_logger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import ephem
      from pylibftdi import BitBangDevice
      import scipy.signal

      # Given longitude(decimal degrees as a float)
      #
      # Return the current sidereal time as a string with
      #  "," separated tokens
      #
      def cur_sidereal(longitude):
          longstr = "%02d" % int(longitude)
          longstr = longstr + ":"
          longitude = abs(longitude)
          frac = longitude - int(longitude)
          frac *= 60
          mins = int(frac)
          longstr += "%02d" % mins
          longstr += ":00"
          x = ephem.Observer()
          x.date = ephem.now()
          x.long = longstr
          jdate = ephem.julian_date(x)
          tokens=str(x.sidereal_time()).split(":")
          hours=int(tokens[0])
          minutes=int(tokens[1])
          seconds=int(float(tokens[2]))
          sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
          return (sidt)


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """4-channel FFT logger with two layers of filters
               fft_size - fixed at 2048
               f1  - channel 1 frequency
               f2  - channel 2 frequency
               f3  - channel 3 frequency
               f4  - channel 4 frequency
               decln   - declination (decimal degrees)
               longitude - longitude (decimal degrees)
               prefix - filename prefix for log files
               logtime  - logging interval, in seconds
               irate   - internal post-FFT sample-rate (Hz)
               caldev  - calibration device identifier (for libpyftdi)
               caltimes  - comma-separated list of LMST times to turn on CAL
               caldur    - CAL duration, in seconds
               bandwidth  - input bandwidth, Hz
               fmode   - filtering mode: 'median', 'min', 'max', "rfi"
               klen - kernel length for rfi mode  3 or 5"""

          def __init__(self, fft_size=2048,f1=1420.4058e6,f2=1420.4058e6,f3=611e6,f4=1000e6,
              decln=0.0,longitude=-76.03,prefix="./", logtime=10.0, irate=10, caldev="", caltimes="", caldur=0.0,
              bandwidth=1e6, fmode="median", klen=3, schedule=""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Logger for multi vectors (FFT)',   # will show up in GRC
                  in_sig=[(np.float32,fft_size)]*4,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fft_size = fft_size
              self.f1 = f1
              self.f2 = f2
              self.f3 = f3
              self.f4 = f4
              self.freqs = [self.f1,self.f2,self.f3,self.f4]
              self.logtime = logtime
              self.decln = decln
              self.prefix = prefix
              self.longitude = longitude
              self.then = time.time()
              self.mdarrays = [[]] * len(self.freqs)
              self.irate = irate
              self.bandwidth = bandwidth
              self.avgarrays = []
              self.avgcount = []
              self.caltimes = caltimes
              self.caldev = caldev
              self.caldur = caldur
              self.fmode = fmode
              self.klen = klen
              self.bbd = None
              self.calstate = "IDLE"
              self.calthen = time.time()
              self.caltime = time.time()
              self.schedule = schedule
              if (self.caldev != None and self.caldev != "" and self.caltimes != "" and
                  self.caltimes != None and self.caldur > 0):
                  self.bbd = BitBangDevice(self.caldev)
                  self.bbd.direction = 0xFF
                  self.bbd.port = 0x00
              for i in range(0,len(self.freqs)):
                  self.avgarrays.append(np.zeros(self.fft_size,dtype=np.float32))
                  self.avgcount.append(0)

          def work(self, input_items, output_items):
              
              #
              # Check if it's time to fire the calibrator
              #
              #
              # Make sure we have a calibrator to fire
              #
              if (self.bbd != None and ((time.time() - self.calthen) >= 1)):
                  self.calthen = time.time()
                  
                  # 
                  # We do the conversion every time, because the "caltimes" parameter
                  #  can actually be changed at runtime via XMLRPC.
                  #
                  self.calfloats = []
                  if (self.caltimes != None and self.caltimes != ""):
                      for x in self.caltimes.split(","):
                          self.calfloats.append(float(x))  
                  
                  #
                  # Pick up current *SIDEREAL* time
                  #
                  st = cur_sidereal(self.longitude)
                  st = st.split(",")
                  st = float(st[0])+float(st[1])/60.0+float(st[2])/3600.0

                  #
                  # If we're in an IDLE state
                  #
                  if (self.calstate == "IDLE"):
                      #
                      # If we have a match
                      #
                      for x in self.calfloats:
                          if (abs(st-x) <= (5.0/3600.0)):
                              self.calstate = "ON"
                              self.bbd.port = 0x01
                              self.caltime = time.time()+self.caldur
                  #
                  # We aren't IDLE...
                  #
                  if (self.calstate == "ON"):
                      #
                      # We've been ON long enough
                      #
                      if (time.time() >= self.caltime):
                          self.calstate = "IDLE"
                          self.bbd.port = 0x00
                          
                  
              #
              # For each input channel
              #
              for x in range(len(input_items)):
                  v = input_items[x]
                  #
                  # For each of the vectors being presented in this channel
                  #
                  for wector in v:
                      #
                      # Update buffer for later median-filter
                      #
                      self.mdarrays[x].append(wector)
              #
              # Time to median-reduce the data over a 1 second interval
              #
              if (len(self.mdarrays[0]) >= self.irate):
                  for x in range(len(self.freqs)):
                      #
                      # Turn it into a first-class Numpy 2D array
                      #
                      a = np.array(self.mdarrays[x])
                      
                      #
                      # Compute median or min or max on transposed axes
                      #

                      #
                      # 1D median
                      #
                      if self.fmode == "median":
                          median = np.median(a.transpose(),axis=1)
                      
                      #
                      # Just he minimum
                      #
                      elif self.fmode == "min":
                          median = np.min(a.transpose(), axis=1)
                      
                      #
                      # or the max
                      #
                      elif self.fmode == "max":
                          median = np.max(a.transpose(), axis=1)
                      
                      #
                      # or the mean
                      #
                      elif self.fmode == "mean":
                          median = np.mean(a.transpose(), axis=1)
                      #
                      # Perform a 2D median filter on the FFT data
                      #
                      # This is often used in de-speckling images
                      # Might work here, also
                      #
                      elif self.fmode == "rfi":
                          a = scipy.signal.medfilt2d(a,kernel_size=self.klen)
                          median = np.mean(a.transpose(), axis=1)
                              
                      self.avgarrays[x] = np.add(self.avgarrays[x], median)
                      self.avgcount[x] += 1
                      
                      #
                      # "Zero out" the corresponding mdarray
                      #
                      self.mdarrays[x] = []
              #
              # Time to average and log
              #
              if ((time.time() - self.then) >= self.logtime):
                  self.then = time.time()
                  for x in range(len(self.freqs)):
                      #
                      # If this avgarray has anything in it
                      #
                      if (self.avgcount[x] > 0):
                          #
                          # Compute average
                          #
                          av = np.divide(self.avgarrays[x], self.avgcount[x])
                          
                          #
                          # Zero-out
                          #
                          self.avgarrays[x] = np.multiply(self.avgarrays[x], 0.0)
                          self.avgcount[x] = 0
                          
                          #
                          # Get timestamps in both UTC and LMST
                          #
                          ltp = time.gmtime()
                          ds = "%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
                          fname = self.prefix+"%04d-%d-" % (int(self.freqs[x]/1.e06), x)
                          fname += ds
                          fname += ".csv"
                          curt = cur_sidereal(self.longitude)
                          
                          #
                          # Use this to do scheduled logging
                          #  based on a schedule of (lmst,duration) tuples
                          #  contained in "self.schedule"
                          #
                          curt_hours = 0
                          if (self.schedule != "" and self.schedule != None):
                              curt_list = curt.split(",")
                              curt_hours = float(curt_list[0])
                              curt_hours += (float(curt_list[1])/60.0)
                              curt_hours += (float(curt_list[2])/3600.0)
                          
                          within_window = False
                          if (self.schedule != "" and self.schedule != None):
                              sch = eval(self.schedule)
                              for sitems in sch:
                                  low = sitems[0]-(sitems[1]/2.0)
                                  high = sitems[0]+(sitems[1]/2.0)
                                  if (curt_hours >= low and curt_hours <= high):
                                      within_window = True
                                      print ("Window True %f %f\n" % (low, high))
                                      print ("center %f span %f\n" % (sitems[0], sitems[1]))
                              
                          #
                          # If there is no schedule, or there is and we're within
                          #  one of the schedules time windows, log
                          #
                          if (self.schedule == "" or self.schedule == None or
                              within_window == True):
                              
                              fp = open(fname, "a")
                              #
                              # Write headers
                              #

                              fp.write("%02d,%02d,%02d" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                              fp.write(",%s," % curt)
                              fp.write("%.2f," % self.decln)
                              fp.write("%.5f," % (self.freqs[x]/1.0e6))
                              fp.write("%d," % (0 if self.calstate != "ON" else 1))
                              fp.write("%d," % int(self.bandwidth/1e6))
                              
                              #
                              # Write data values
                              #
                              l=len(av)
                              for v in av:
                                  fp.write("%.6e" % v)
                                  l -= 1
                                  if (l > 0):
                                      fp.write(",")
                              fp.write("\n")
                              fp.close()
                          
                      
                    
              return len(input_items[0])
    bandwidth: srate
    caldev: caldev
    caldur: caldur
    caltimes: caltimes
    decln: decln
    f1: f1
    f2: f2
    f3: f3
    f4: f4
    fft_size: fft_size
    fmode: fmode
    irate: irate
    klen: klen
    logtime: logtime
    longitude: longitude
    prefix: prefix
    schedule: schedule
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fmode
  id: parameter
  parameters:
    label: '"RFI filter mode"'
    type: str
    value: '"median"'
  states: {}
- name: g1
  id: parameter
  parameters:
    label: '"Channel 1 gain"'
    type: eng_float
    value: '85.0'
  states: {}
- name: g2
  id: parameter
  parameters:
    label: '"Channel 2 gain"'
    type: eng_float
    value: '85.0'
  states: {}
- name: g3
  id: parameter
  parameters:
    label: '"Channel 3 gain"'
    type: eng_float
    value: '85.0'
  states: {}
- name: g4
  id: parameter
  parameters:
    label: '"Channel 4 gain"'
    type: eng_float
    value: '85.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import ra_funcs
  states: {}
- name: integ
  id: parameter
  parameters:
    label: '"Integration time, seconds"'
    type: eng_float
    value: '2.0'
  states: {}
- name: klen
  id: parameter
  parameters:
    label: '"Kernel Len for ''rfi'' mode"'
    type: intx
    value: '3'
  states: {}
- name: logtime
  id: parameter
  parameters:
    label: '"Logging time, seconds"'
    type: eng_float
    value: '5.0'
  states: {}
- name: longitude
  id: parameter
  parameters:
    label: '"Local longitude"'
    type: eng_float
    value: '-76.0413'
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: '"File prefix"'
    type: str
    value: '"./"'
  states: {}
- name: schedule
  id: parameter
  parameters:
    label: '"Logging schedule (as list of tuples"'
    type: str
    value: '""'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/integ,(srate/fft_size))
    type: float
    vlen: fft_size
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/integ, (srate/fft_size))
    type: float
    vlen: fft_size
  states: {}
- name: single_pole_iir_filter_xx_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/integ,(srate/fft_size))
    type: float
    vlen: fft_size
  states: {}
- name: single_pole_iir_filter_xx_0_0_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: ra_funcs.getalpha(1.0/integ,(srate/fft_size))
    type: float
    vlen: fft_size
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 1.0e6
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    ant1: RX2
    ant2: RX1
    ant3: RX2
    center_freq0: f1
    center_freq1: f2
    center_freq2: f3
    center_freq3: f4
    clock_rate: 200e6
    clock_source0: external
    dev_addr: addr=192.168.40.2,type=x300
    dev_args: master_clock_rate=200e6
    gain0: g1
    gain1: g2
    gain2: g3
    gain3: g4
    lo_export0: 'True'
    lo_export1: 'False'
    lo_export2: 'False'
    lo_export3: 'False'
    lo_source1: companion
    lo_source2: internal
    lo_source3: internal
    nchan: '4'
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: '"A:0 A:1 B:0 B:1"'
    show_lo_controls: 'True'
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '31420'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:14200
    timeout: '100'
    type: float
    vlen: fft_size
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', single_pole_iir_filter_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', single_pole_iir_filter_xx_0_0_0_0, '0']
- [blocks_interleave_0, '0', zeromq_pub_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_interleave_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_logger, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_interleave_0, '1']
- [blocks_keep_one_in_n_0_0, '0', fft_logger, '1']
- [blocks_keep_one_in_n_0_0_0, '0', blocks_interleave_0, '2']
- [blocks_keep_one_in_n_0_0_0, '0', fft_logger, '2']
- [blocks_keep_one_in_n_0_0_0_0, '0', blocks_interleave_0, '3']
- [blocks_keep_one_in_n_0_0_0_0, '0', fft_logger, '3']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [fft_vxx_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [single_pole_iir_filter_xx_0_0_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [single_pole_iir_filter_xx_0_0_0_0, '0', blocks_keep_one_in_n_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '1', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source_0, '2', blocks_stream_to_vector_0_0_0, '0']
- [uhd_usrp_source_0, '3', blocks_stream_to_vector_0_0_0_0, '0']

metadata:
  file_format: 1
