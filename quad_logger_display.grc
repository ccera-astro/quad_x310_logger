options:
  parameters:
    generate_options: qt_gui
    id: quad_logger_display
    output_language: python
    title: Quad Logger Dsiplay
  states: {}

blocks:
- name: log10_k
  id: variable
  parameters:
    value: '-20*math.log10(fft_size)-10*math.log10(winpower/fft_size)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: winpower
  id: variable
  parameters:
    value: sum([x*x for x in window.blackman_harris(fft_size)])
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '4'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: log10_k
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: log10_k
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: log10_k
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: log10_k
    n: '10'
    vlen: fft_size
  states: {}
- name: f1
  id: parameter
  parameters:
    label: Channel 1 Freq
    type: eng_float
    value: 1410e6
  states: {}
- name: f2
  id: parameter
  parameters:
    label: Channel 2 Freq
    type: eng_float
    value: 1410e6
  states: {}
- name: f3
  id: parameter
  parameters:
    label: Channel 3 Freq
    type: eng_float
    value: 611e6
  states: {}
- name: f4
  id: parameter
  parameters:
    label: Channel 4 Freq
    type: eng_float
    value: 1000e6
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: '2048'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import ra_funcs
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: '"%.3fMHz" % (f1 / 1.0e6)'
    label2: '"%.3fMHz" % (f2 / 1.0e6)'
    label3: '"%.3fMHz" % (f3 / 1.0e6)'
    label4: '"%.3fMHz" % (f4 / 1.0e6)'
    name: '"Spectrum"'
    nconnections: '4'
    vlen: fft_size
    x_axis_label: '"Frequency Offset"'
    x_start: '-(samp_rate/2)'
    x_step: samp_rate/fft_size
    y_axis_label: '"dB"'
    ymin: '-100'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 10e6
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:14200
    timeout: '100'
    type: float
    vlen: fft_size
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_deinterleave_0, '1', blocks_nlog10_ff_0_0, '0']
- [blocks_deinterleave_0, '2', blocks_nlog10_ff_0_0_0, '0']
- [blocks_deinterleave_0, '3', blocks_nlog10_ff_0_0_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_vector_sink_f_0, '2']
- [blocks_nlog10_ff_0_0_0_0, '0', qtgui_vector_sink_f_0, '3']
- [zeromq_sub_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
